## kernel/drivers/vireg/Kconfig
```kconfig
config VIREG
    tristate "vireg driver"
    default y
    help
    This is the virtual driver for android driver test.
```
